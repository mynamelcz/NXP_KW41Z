# Keil uVision project cmsis_dspi_edma_b2b_transfer_master.uvprojx, settings and files
target cmsis_dspi_edma_b2b_transfer_master Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  c define: DEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ..\CMSIS\Include;..\devices;..\CMSIS\Driver\Include;..\devices\MKW41Z4\drivers;..\devices\MKW41Z4\cmsis_drivers;..\devices\MKW41Z4\utilities;..\devices\MKW41Z4;..\CMSIS\Include;..\..\WK41Z_CODE;..\devices\MKW41Z4\drivers;..\DEV\SPI_SD;..\USER\common;..\..\NXP_KW41Z
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW41Z512xxx4_flash.scf
  link misc: --remove
  group startup
    ../devices/MKW41Z4/: system_MKW41Z4.c
    ../devices/MKW41Z4/arm/: startup_MKW41Z4.s
  group doc
    ../: readme.txt
  group drivers
    ../devices/MKW41Z4/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_cop.c fsl_dac.c fsl_dcdc.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_flash.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ltc.c fsl_ltc_edma.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sim.c fsl_smc.c fsl_tpm.c fsl_trng.c fsl_tsi_v4.c fsl_vref.c
    ../devices/MKW41Z4/cmsis_drivers/: fsl_dspi_cmsis.c fsl_i2c_cmsis.c fsl_lpuart_cmsis.c
  group source
    ../: cmsis_dspi_edma_b2b_transfer_master.c
  group board
    ../: pin_mux.c pin_mux.h RTE_Device.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../devices/MKW41Z4/utilities/: fsl_debug_console.c fsl_notifier.c fsl_sbrk.c
  group DEV
    ../DEV/SPI_SD/: spi_sd.c
  group USER
    ../USER/common/: common.c
target cmsis_dspi_edma_b2b_transfer_master Release (ARM-ADS)
  device: MKW41Z512xxx4 Freescale
  pack: Keil.Kinetis_KWxx_DFP.1.9.0
  cpu: CPUTYPE("Cortex-M0+")
  output: cmsis_dspi_edma_b2b_transfer_master.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKW41Z512VHT4, FRDM_KW41Z, FREEDOM
  c misc: as above
  c include: ../../../../../../../CMSIS/Include;../../../../../../../devices;..;../../../../../../../CMSIS/Driver/Include;../../../../..;../../../../../../../devices/MKW41Z4/drivers;../../../../../../../devices/MKW41Z4/cmsis_drivers;../../../../../../../devices/MKW41Z4/utilities;../../../../../../../devices/MKW41Z4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKW41Z512xxx4_flash.scf
  link misc: --remove
